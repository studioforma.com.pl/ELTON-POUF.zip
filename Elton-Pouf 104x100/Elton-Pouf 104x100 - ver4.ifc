Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Elton-Pouf 104x100 - ver4.ifc
Time: 2025-11-02T23:06:12
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Elton-Pouf 104x100_0 - ObjectType: SketchupGroup
 | Elton-Pouf 104x100_1 - ObjectType: SketchupGroup
 | Elton-Pouf 104x100_2 - ObjectType: SketchupGroup
 | Elton-Pouf 104x100_3 - ObjectType: SketchupGroup
